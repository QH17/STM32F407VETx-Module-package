# Keil uVision project TEMP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEMP
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --cpp11
  c include: ..\CORE;..\FWLIB\inc;..\FWLIB\src;..\SYSTEM\delay;..\SYSTEM\Include;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE;..\DSP;..\DSP\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: stm32f4xx_it.c stm32f4xx_conf.h main.cpp
  group SYSTEM
    ../USER/: stm32f4xx.h system_stm32f4xx.c
    ../CORE/: core_cm4.h
  group SYS
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group STARTCODE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWlib
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_tim.c
  group HARDWARE
    ../HARDWARE/: lcd.c LCD_CPP.cpp ADC.cpp ADC.h Interrupt.c COUNTER.cpp
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
